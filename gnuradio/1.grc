options:
  parameters:
    author: test
    generate_options: qt_gui
    id: test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/test/1080p
    type: complex
  states: {}
- name: paint_image_source_0
  id: paint_image_source
  parameters:
    autocontrast: '0'
    bt709_map: '1'
    image_file: /home/test/1.jpg
    image_flip: '0'
    image_invert: '0'
    repeatmode: '0'
  states: {}
- name: paint_paint_bc_0
  id: paint_paint_bc
  parameters:
    equalization: EQUALIZATION_OFF
    randomsrc: INTERNAL
    repeats: '8'
    width: '1920'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [paint_image_source_0, '0', paint_paint_bc_0, '0']
- [paint_paint_bc_0, '0', blocks_file_sink_0, '0']
- [paint_paint_bc_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
